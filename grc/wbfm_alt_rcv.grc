options:
  parameters:
    author: David P
    category: '[Modulators]'
    description: Alternate FM receiver algorithm
    generate_options: hb
    id: wbfm_alt_rcv
    output_language: python
    title: 'WBFM Alternate Receiver '
  states: {}

blocks:
- name: audio_rate
  id: parameter
  parameters:
    label: Audio Rate
    type: intx
    value: int(48e3)
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '15'
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    comment: '[0.0005, -0.0017,  0.0032, -0.0052,  0.0079, -0.0115,  0.0162, -0.0223,  0.0302, -0.0406,  0.0548, -0.0752,  0.1077, -0.1699,  0.3502, 0, -0.3502,  0.1699, -0.1077,  0.0752, -0.0548,  0.0406, -0.0302,  0.0223, -0.0162,  0.0115, -0.0079,  0.0052, -0.0032,  0.0017, -0.0005]'
    decim: '1'
    samp_rate: samp_rate
    taps: '[0.0005, -0.0017,  0.0032, -0.0052,  0.0079, -0.0115,  0.0162, -0.0223,  0.0302, -0.0406,  0.0548, -0.0752,  0.1077, -0.1699,  0.3502, 0, -0.3502,  0.1699, -0.1077,  0.0752, -0.0548,  0.0406, -0.0302,  0.0223, -0.0162,  0.0115, -0.0079,  0.0052, -0.0032,  0.0017, -0.0005]'
    type: ccc
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0_1
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate)
    interp: audio_rate
    taps: ''
    type: fff
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: intx
    value: int(240e3)
  states: {}

connections:
- [blocks_complex_to_float_0, '0', blocks_multiply_xx_1, '0']
- [blocks_complex_to_float_0, '1', blocks_multiply_xx_0, '0']
- [blocks_complex_to_float_0_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_float_0_0, '1', blocks_multiply_xx_1, '1']
- [blocks_complex_to_mag_squared_0, '0', blocks_divide_xx_0, '1']
- [blocks_delay_0, '0', blocks_complex_to_float_0, '0']
- [blocks_divide_xx_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_sub_xx_0, '1']
- [blocks_multiply_xx_1, '0', blocks_sub_xx_0, '0']
- [blocks_sub_xx_0, '0', blocks_divide_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_float_0_0, '0']
- [pad_source_0_1, '0', blocks_complex_to_mag_squared_0, '0']
- [pad_source_0_1, '0', blocks_delay_0, '0']
- [pad_source_0_1, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rational_resampler_xxx_0_0, '0', pad_sink_0, '0']

metadata:
  file_format: 1
